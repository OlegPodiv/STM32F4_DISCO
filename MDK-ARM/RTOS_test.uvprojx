# Keil uVision project RTOS_test.uvprojx, settings and files
target RTOS_test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RTOS_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;                                                                                              ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                                              ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                                              ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                                                              ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                                                                              ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;                                                                                              ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                                              ../Drivers/CMSIS/Include;                                                                                              ../Drivers/DS3231;                                                                                              ../Middlewares/Third_Party/FatFs/src;                                                                                              ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;                                                                                              ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc;                                                                                              ../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;                                                                                              ../Drivers/ds18b20Lib
  asm include: ..\\Inc;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: stm32_ds3231.c user_tasks.c sensors.c global_var.c FreeRTOS_CLI.c main_module.c main.c freertos.c usbh_diskio.c fatfs.c pdm2pcm.c usb_host.c usbh_conf.c usbh_platform.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/ds18b20Lib
    ../Drivers/ds18b20Lib/: ds18b20.c onewire.c ds18b20.h ds18b20Config.h onewire.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/PDMFilter
    ../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
software components: CMSIS:CORE 5.3.0
